# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\IIC;..\HARDWARE\USART4;..\HARDWARE\MOTOR;..\HARDWARE\ENCODER;..\HARDWARE\PWM;..\HARDWARE\PID;..\HARDWARE\CONTROL;..\HARDWARE\DATASCOPE;..\HARDWARE\MQTT;..\HARDWARE\SPI;..\HARDWARE\OLED_SPI;..\HARDWARE\DHT11;..\HARDWARE\UART5;..\HARDWARE\usart1;..\HARDWARE\Servo;..\HARDWARE\wit_c_sdk
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/USART4/: usart4.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/CONTROL/: control.c xunji.c
    ../HARDWARE/DATASCOPE/: datascope.c
    ../HARDWARE/MQTT/: MQTT.c UART.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/OLED_SPI/: OLED_SPI.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/UART5/: UART5.c
    ../HARDWARE/Servo/: Servo.c
    ../HARDWARE/wit_c_sdk/: wit_c_sdk.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
